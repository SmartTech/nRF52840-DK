# IAR project blinky_pca10056.ewp, settings and files
configuration nrf52840_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52840_xxaa nRF52840_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: BOARD_PCA10056; BSP_DEFINES_ONLY; CONFIG_GPIO_AS_PINRESET; FLOAT_ABI_HARD; NRF52840_XXAA
  ICCARM.CCIncludePath2: D:\Projects\Vega\nRF52840-DK\IAR\pca10056\blank\config; D:\Projects\Vega\nRF5_SDK_14.2.0\components; D:\Projects\Vega\nRF5_SDK_14.2.0\components\boards; D:\Projects\Vega\nRF5_SDK_14.2.0\components\device; D:\Projects\Vega\nRF5_SDK_14.2.0\components\drivers_nrf\delay; D:\Projects\Vega\nRF5_SDK_14.2.0\components\drivers_nrf\hal; D:\Projects\Vega\nRF5_SDK_14.2.0\components\drivers_nrf\nrf_soc_nosd; D:\Projects\Vega\nRF5_SDK_14.2.0\components\libraries\balloc; D:\Projects\Vega\nRF5_SDK_14.2.0\components\libraries\bsp; D:\Projects\Vega\nRF5_SDK_14.2.0\components\libraries\experimental_log; D:\Projects\Vega\nRF5_SDK_14.2.0\components\libraries\experimental_log\src; D:\Projects\Vega\nRF5_SDK_14.2.0\components\libraries\experimental_memobj; D:\Projects\Vega\nRF5_SDK_14.2.0\components\libraries\experimental_section_vars; D:\Projects\Vega\nRF5_SDK_14.2.0\components\libraries\strerror; D:\Projects\Vega\nRF5_SDK_14.2.0\components\libraries\util; D:\Projects\Vega\nRF5_SDK_14.2.0\components\toolchain; D:\Projects\Vega\nRF5_SDK_14.2.0\components\toolchain\cmsis\include; D:\Projects\Vega\nRF5_SDK_14.2.0\components\toolchain\cmsis\include; ..\..\..; ..\config; D:\Projects\Vega\nRF52840-DK\PlatformIO; D:\Projects\Vega\nRF52840-DK\PlatformIO\src\MBED_test; D:\Projects\Vega\nRF52840-DK\PlatformIO\lib
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 1
  AARM.ADefines: as above
  AARM.AUserIncludes: ..\..\..\config; ..\..\..\..\..\..\components; ..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\..\components\libraries\bsp; ..\..\..\..\..\..\components\libraries\experimental_log; ..\..\..\..\..\..\components\libraries\experimental_log\src; ..\..\..\..\..\..\components\libraries\experimental_memobj; ..\..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..; ..\config
  OBJCOPY.OOCOutputFile: blinky_pca10056.hex
  ILINK.IlinkOutputFile: blinky_pca10056.out
  ILINK.IlinkIcfFile: blinky_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../../../src/: main.cpp
  group Board Definition
    ../../../../../nRF5_SDK_14.2.0/components/boards/: boards.c
  group Device
    ../../../../../nRF5_SDK_14.2.0/components/toolchain/iar/: iar_startup_nrf52840.s
    ../../../../../nRF5_SDK_14.2.0/components/toolchain/: system_nrf52840.c
  group nRF_Libraries
    ../../../../../nRF5_SDK_14.2.0/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../nRF5_SDK_14.2.0/components/libraries/strerror/: nrf_strerror.c
